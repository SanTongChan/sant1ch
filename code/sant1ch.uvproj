# Keil uVision project sant1ch.uvproj, settings and files
target sant1ch (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: sant1ch +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\code\common;.\code\driver;.\code\flash;.\code\key;.\code\led;.\code\logic;.\code\remote;.\code\sant1ch;.\code\timer
  group timer
    ./code/timer/: timer.c
  group logic
    ./code/logic/: logic.c
  group key
    ./code/key/: key.c
  group startup
    ./: STARTUP.A51
  group sant1ch
    ./code/sant1ch/: main.c
  group driver
    ./code/driver/: key_driver.c
  group led
    ./code/led/: led.c
  group flash
    ./code/flash/: flash.c
  group remote
    ./code/remote/: remote.c
